# Keil uVision project OileHeat5.uvprojx, settings and files
target OileHeat5 Configuration (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x6,STM32_PLATEFORM
  c misc: --C99
  c include: ../Inc;   ../Drivers/STM32F0xx_HAL_Driver/Inc;   ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Include;   ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;   ..\..\PC_HeatDemo\Heat\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030x6.s
  group Heat
    ../../PC_HeatDemo/Heat/Src/: alarm.c heat.c key.c parm.c pwm.c StateMachine.c time.c comm.c port.c queue.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_cortex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal.c stm32f0xx_hal_pwr.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Application/User
    ../Src/: stm32f0xx_hal_msp.c stm32f0xx_it.c main.c
software components: CMSIS:CORE 4.3.0
